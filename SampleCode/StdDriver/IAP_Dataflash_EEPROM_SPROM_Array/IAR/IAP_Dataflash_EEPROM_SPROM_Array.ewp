# IAR project IAP_Dataflash_EEPROM_SPROM_Array.ewp, settings and files
configuration Debug (8051, debug)
  General.OGChipSelectMenu: MUG51 MUG51
  ICC8051.CCDefines: FOSC_160000=1
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\..\..\Library\Device\Include; ..\..\..\..\Library\StdDriver\inc
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  A8051.ADefines: FOSC_160000
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\NuvoTon\lnk51ew_ML51.xcl
configuration Release (8051)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: N76E003 N76E003
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../../../../Library/StdDriver/src/: Common.c eeprom_sprom.c sys.c uart.c
    ../: IAP_EEPROM_SPROM.c
